# IAR project btsensor.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG22C200F512IM32 SiliconLaboratories EFM32PG22C200F512IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG_EFM=1; EFM32PG22C200F512IM32=1; SL_CODE_COMPONENT_SYSTEM=system; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; SL_COMPONENT_CATALOG_PRESENT=1; SL_CODE_COMPONENT_DEVICE_PERIPHERAL=device_peripheral; SL_CODE_COMPONENT_DMA_CHANNEL=dma_channel; SL_CODE_COMPONENT_DMA_MANAGER=dma_manager; SL_CODE_COMPONENT_GPIO=gpio; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_HAL_LDMA=hal_ldma; SL_CODE_COMPONENT_INTERRUPT_MANAGER=interrupt_manager; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; SL_CODE_COMPONENT_MEMORY_MANAGER=memory_manager; SL_CODE_COMPONENT_POWER_MANAGER=power_manager; SL_CODE_COMPONENT_CORE=core; SL_CODE_COMPONENT_SLEEPTIMER=sleeptimer; SL_CODE_COMPONENT_SPIDRV=spidrv
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; .; simplicity_sdk_2026.6.0\platform_core\platform\Device\SiliconLabs\EFM32PG22\Include; simplicity_sdk_2026.6.0\platform_core\platform\common\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\clock_manager\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\clock_manager\src; simplicity_sdk_2026.6.0\cmsis\Core\Include; simplicity_sdk_2026.6.0\cmsis\Core\Include\m-profile; simplicity_sdk_2026.6.0\cmsis\Core\Include\a-profile; simplicity_sdk_2026.6.0\platform_core\platform\service\device_manager\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\device_init\inc; simplicity_sdk_2026.6.0\platform_core\platform\driver\dma_channel\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\dma_manager\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\dma_manager\src; simplicity_sdk_2026.6.0\platform_core\platform\emdrv\common\inc; simplicity_sdk_2026.6.0\platform_core\platform\emlib\inc; simplicity_sdk_2026.6.0\platform_core\platform\common\errno_error_codes\inc; simplicity_sdk_2026.6.0\platform_core\platform\driver\gpio\inc; simplicity_sdk_2026.6.0\platform_core\platform\peripheral\inc; simplicity_sdk_2026.6.0\platform_core\platform\peripheral\init\gpio_simple; simplicity_sdk_2026.6.0\platform_core\platform\driver\i2c\inc; simplicity_sdk_2026.6.0\platform_core\platform\driver\i2c\src; simplicity_sdk_2026.6.0\platform_core\platform\driver\i2cspm\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\interrupt_manager\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\interrupt_manager\src; simplicity_sdk_2026.6.0\platform_core\platform\service\interrupt_manager\inc\arm; simplicity_sdk_2026.6.0\platform_core\platform\service\iostream\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\memory_manager\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\memory_manager\src; simplicity_sdk_2026.6.0\platform_core\platform\emdrv\nvm3\inc; simplicity_sdk_2026.6.0\platform_core\platform\emdrv\nvm3\config; simplicity_sdk_2026.6.0\platform_core\platform\service\power_manager\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\power_manager\src\common; simplicity_sdk_2026.6.0\platform_core\platform\service\power_manager\src\sleep_loop; simplicity_sdk_2026.6.0\platform_core\platform\service\sl_main\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\sl_main\src; simplicity_sdk_2026.6.0\platform_core\platform\service\sleeptimer\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\sleeptimer\src; simplicity_sdk_2026.6.0\platform_core\platform\emdrv\spidrv\inc; simplicity_sdk_2026.6.0\platform_core\platform\emdrv\tempdrv\inc; simplicity_sdk_2026.6.0\platform_core\platform\service\udelay\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: btsensor.s37
  ILINK.IlinkOutputFile: btsensor.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: adc.c adc.h btsensor.ipcf comm.c comm.h config.c config.h crc.c crc.h env.c env.h tasks.c tasks.h timer.c timer.h tmp1075.c tmp1075.h tpl0501.c tpl0501.h uart.c uart.h
  group Simplicity Configurator
    ./: AGENTS.md app.c app.h main.c readme.md
  group Simplicity Configurator/autogen
    autogen/: AGENTS-SLAB.md gen.properties linkerfile.icf RTE_Components.h sl_component_catalog.h sl_dma_manager_instances.c sl_dma_manager_instances.h sl_event_handler.c sl_event_handler.h sl_hal_gpio_simple_init.c sl_i2cspm_init.c sl_i2cspm_instances.h sl_iostream_handles.c sl_iostream_handles.h sl_iostream_init_eusart_instances.c sl_iostream_init_eusart_instances.h sl_iostream_init_instances.h sl_power_manager_handler.c sl_spidrv_init.c sl_spidrv_instances.h
  group Simplicity Configurator/autogen/.slc_state
    autogen/.slc_state/: .crc_config.crc
  group Simplicity Configurator/config
    config/: nvm3_default_config.h sl_clock_manager_oscillator_config.h sl_clock_manager_tree_config.h sl_core_config.h sl_device_init_dcdc_config.h sl_hal_gpio_init_pa00_config.h sl_i2cspm_tmp1075_config.h sl_iostream_eusart_inst0_config.h sl_memory_manager_config.h sl_memory_manager_region_config.h sl_power_manager_config.h sl_sleeptimer_config.h sl_spidrv_tpl0501_config.h spidrv_config.h tempdrv_config.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/cmsis/Core/Include
    simplicity_sdk_2026.6.0/cmsis/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h sli_cmsis_deprecated_aliases.h tz_context.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/cmsis/Core/Include/m-profile
    simplicity_sdk_2026.6.0/cmsis/Core/Include/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/common/errno_error_codes/inc
    simplicity_sdk_2026.6.0/platform_core/platform/common/errno_error_codes/inc/: errno_error_codes.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/common/inc
    simplicity_sdk_2026.6.0/platform_core/platform/common/inc/: sl_assert.h sl_atomic.h sl_bit.h sl_code_classification.h sl_common.h sl_compiler.h sl_core.h sl_enum.h sl_slist.h sl_status.h sl_string.h sli_code_classification.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/common/src
    simplicity_sdk_2026.6.0/platform_core/platform/common/src/: sl_assert.c sl_core_cortexm.c sl_slist.c sl_string.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/Device/SiliconLabs/EFM32PG22/Include
    simplicity_sdk_2026.6.0/platform_core/platform/Device/SiliconLabs/EFM32PG22/Include/: efm32pg22_buram.h efm32pg22_burtc.h efm32pg22_cmu.h efm32pg22_cryptoacc.h efm32pg22_dcdc.h efm32pg22_devinfo.h efm32pg22_dma_descriptor.h efm32pg22_dpll.h efm32pg22_emu.h efm32pg22_eusart.h efm32pg22_fsrco.h efm32pg22_gpcrc.h efm32pg22_gpio.h efm32pg22_gpio_port.h efm32pg22_hfrco.h efm32pg22_hfxo.h efm32pg22_i2c.h efm32pg22_iadc.h efm32pg22_icache.h efm32pg22_ldma.h efm32pg22_ldmaxbar.h efm32pg22_ldmaxbar_defines.h efm32pg22_letimer.h efm32pg22_lfrco.h efm32pg22_lfxo.h efm32pg22_msc.h efm32pg22_pdm.h efm32pg22_prs.h efm32pg22_prs_signals.h efm32pg22_rtcc.h efm32pg22_smu.h efm32pg22_syscfg.h efm32pg22_timer.h efm32pg22_ulfrco.h efm32pg22_usart.h efm32pg22_wdog.h efm32pg22c200f512im32.h em_device.h system_efm32pg22.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/Device/SiliconLabs/EFM32PG22/Source
    simplicity_sdk_2026.6.0/platform_core/platform/Device/SiliconLabs/EFM32PG22/Source/: startup_efm32pg22.c system_efm32pg22.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/dma_channel/inc
    simplicity_sdk_2026.6.0/platform_core/platform/driver/dma_channel/inc/: sl_dma_channel.h sl_dma_channel_device.h sl_dma_descriptor_allocator.h sli_dma_channel.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/dma_channel/src
    simplicity_sdk_2026.6.0/platform_core/platform/driver/dma_channel/src/: sl_dma_channel.c sl_dma_descriptor_allocator.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/gpio/inc
    simplicity_sdk_2026.6.0/platform_core/platform/driver/gpio/inc/: sl_gpio.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/gpio/src
    simplicity_sdk_2026.6.0/platform_core/platform/driver/gpio/src/: sl_gpio.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/i2c/inc
    simplicity_sdk_2026.6.0/platform_core/platform/driver/i2c/inc/: sl_i2c.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/i2c/src
    simplicity_sdk_2026.6.0/platform_core/platform/driver/i2c/src/: sl_i2c.c sli_i2c.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/i2cspm/inc
    simplicity_sdk_2026.6.0/platform_core/platform/driver/i2cspm/inc/: sl_i2cspm.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/driver/i2cspm/src
    simplicity_sdk_2026.6.0/platform_core/platform/driver/i2cspm/src/: sl_i2cspm.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/common/inc
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/common/inc/: ecode.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/nvm3/config
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/nvm3/config/: nvm3_config.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/nvm3/inc
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/nvm3/inc/: nvm3.h nvm3_cache.h nvm3_default.h nvm3_generic.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h nvm3_object.h nvm3_page.h nvm3_trace.h nvm3_utils.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/nvm3/src
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/nvm3/src/: nvm3.c nvm3_cache.c nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c nvm3_object.c nvm3_page.c nvm3_utils.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/spidrv/inc
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/spidrv/inc/: spidrv.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/spidrv/src
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/spidrv/src/: spidrv.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/tempdrv/inc
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/tempdrv/inc/: tempdrv.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emdrv/tempdrv/src
    simplicity_sdk_2026.6.0/platform_core/platform/emdrv/tempdrv/src/: tempdrv.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emlib/inc
    simplicity_sdk_2026.6.0/platform_core/platform/emlib/inc/: em_assert.h em_burtc.h em_bus.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_core_generic.h em_emu.h em_eusart.h em_eusart_compat.h em_gpio.h em_i2c.h em_iadc.h em_msc.h em_msc_compat.h em_ramfunc.h em_rtcc.h em_syscfg.h em_system.h em_system_generic.h em_timer.h em_usart.h em_version.h sli_em_cmu.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/emlib/src
    simplicity_sdk_2026.6.0/platform_core/platform/emlib/src/: em_burtc.c em_cmu.c em_emu.c em_eusart.c em_gpio.c em_i2c.c em_iadc.c em_msc.c em_rtcc.c em_system.c em_timer.c em_usart.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/peripheral/inc
    simplicity_sdk_2026.6.0/platform_core/platform/peripheral/inc/: sl_hal_bus.h sl_hal_eusart.h sl_hal_gpcrc.h sl_hal_gpio.h sl_hal_i2c.h sl_hal_iadc.h sl_hal_ldma.h sl_hal_letimer.h sl_hal_prs.h sl_hal_prs_enums.h sl_hal_syscfg.h sl_hal_system.h sl_hal_system_generic.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/peripheral/init/gpio_simple
    simplicity_sdk_2026.6.0/platform_core/platform/peripheral/init/gpio_simple/: sl_hal_gpio_simple_init.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/peripheral/src
    simplicity_sdk_2026.6.0/platform_core/platform/peripheral/src/: sl_hal_eusart.c sl_hal_gpcrc.c sl_hal_gpio.c sl_hal_i2c.c sl_hal_iadc.c sl_hal_ldma.c sl_hal_letimer.c sl_hal_prs.c sl_hal_syscfg.c sl_hal_system.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/clock_manager/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/clock_manager/inc/: sl_clock_manager.h sl_clock_manager_init.h sli_clock_manager.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/clock_manager/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/clock_manager/src/: sl_clock_manager.c sl_clock_manager_hal_s2.c sl_clock_manager_init.c sl_clock_manager_init_hal_s2.c sli_clock_manager_hal.h sli_clock_manager_init_hal.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_init/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_init/inc/: sl_device_init_dcdc.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_init/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_init/src/: sl_device_init_dcdc_s2.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/clocks
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/clocks/: sl_device_clock_efr32xg22.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/devices
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/devices/: sl_device_peripheral_hal_efr32xg22.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/dma
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/dma/: sl_device_dma_s2.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/inc/: sl_device_clock.h sl_device_dma.h sl_device_gpio.h sl_device_i2c.h sl_device_peripheral.h sl_device_peripheral_types.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/device_manager/src/: sl_device_clock.c sl_device_dma.c sl_device_gpio.c sl_device_peripheral.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/dma_manager/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/dma_manager/inc/: sl_dma_manager.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/dma_manager/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/dma_manager/src/: sl_dma_manager.c sl_dma_manager_hal_ldma.c sli_dma_manager_internal.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/interrupt_manager/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/interrupt_manager/inc/: sl_interrupt_manager.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/interrupt_manager/inc/arm
    simplicity_sdk_2026.6.0/platform_core/platform/service/interrupt_manager/inc/arm/: cmsis_nvic_virtual.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/interrupt_manager/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/interrupt_manager/src/: sl_interrupt_manager_cortexm.c sli_interrupt_manager.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/iostream/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/iostream/inc/: sl_iostream.h sl_iostream_eusart.h sl_iostream_uart.h sli_iostream.h sli_iostream_dmadrv.h sli_iostream_uart.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/iostream/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/iostream/src/: sl_iostream.c sl_iostream_dmadrv.c sl_iostream_eusart.c sl_iostream_uart.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/memory_manager/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/memory_manager/inc/: sl_memory_manager.h sl_memory_manager_region.h sli_memory_manager_retention_control.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/memory_manager/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/memory_manager/src/: sl_memory_manager.c sl_memory_manager_dynamic_reservation.c sl_memory_manager_pool.c sl_memory_manager_pool_common.c sl_memory_manager_region.c sl_memory_manager_retarget.c sli_memory_manager.h sli_memory_manager_common.c
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/power_manager/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/power_manager/inc/: sl_power_manager.h sl_power_manager_debug.h sli_power_manager.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/power_manager/src/common
    simplicity_sdk_2026.6.0/platform_core/platform/service/power_manager/src/common/: sl_power_manager_common.c sl_power_manager_em4.c sli_power_manager_common_private.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/power_manager/src/sleep_loop
    simplicity_sdk_2026.6.0/platform_core/platform/service/power_manager/src/sleep_loop/: sl_power_manager.c sl_power_manager_debug.c sl_power_manager_hal_s2.c sli_power_manager_private.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/sl_main/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/sl_main/inc/: sl_main_init.h sl_main_init_memory.h sl_main_process_action.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/sl_main/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/sl_main/src/: sl_main_init.c sl_main_init_memory.c sl_main_process_action.c sli_main_init_memory.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/sleeptimer/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/sleeptimer/inc/: sl_sleeptimer.h sli_sleeptimer.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/sleeptimer/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_burtc.c sl_sleeptimer_hal_rtcc.c sl_sleeptimer_hal_timer.c sli_sleeptimer_hal.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/udelay/inc
    simplicity_sdk_2026.6.0/platform_core/platform/service/udelay/inc/: sl_udelay.h
  group Simplicity Configurator/simplicity_sdk_2026.6.0/platform_core/platform/service/udelay/src
    simplicity_sdk_2026.6.0/platform_core/platform/service/udelay/src/: sl_udelay.c sl_udelay_armv6m_iar.s
