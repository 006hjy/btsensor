# IAR project Backup of btsensor.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG22C200F512IM32 SiliconLaboratories EFM32PG22C200F512IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG_EFM=1; EFM32PG22C200F512IM32=1; SL_CODE_COMPONENT_SYSTEM=system; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; SL_COMPONENT_CATALOG_PRESENT=1; SL_CODE_COMPONENT_GPIO=gpio; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_INTERRUPT_MANAGER=interrupt_manager; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; SL_CODE_COMPONENT_CORE=core
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; .; simplicity_sdk_2025.12.3\devices\platform\Device\SiliconLabs\EFM32PG22\Include; simplicity_sdk_2025.12.3\platform_core\platform\service\clock_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\clock_manager\src; simplicity_sdk_2025.12.3\cmsis\Core\Include; simplicity_sdk_2025.12.3\platform_common\platform\common\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\device_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\device_init\inc; simplicity_sdk_2025.12.3\platform_core\platform\emlib\inc; simplicity_sdk_2025.12.3\platform_core\platform\driver\gpio\inc; simplicity_sdk_2025.12.3\platform_core\platform\peripheral\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\interrupt_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\interrupt_manager\src; simplicity_sdk_2025.12.3\platform_core\platform\service\interrupt_manager\inc\arm; simplicity_sdk_2025.12.3\platform_core\platform\service\memory_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\common\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\sl_main\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\sl_main\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: btsensor.s37
  ILINK.IlinkOutputFile: btsensor.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: btsensor.ipcf
  group Simplicity Configurator
    ./: AGENTS.md
